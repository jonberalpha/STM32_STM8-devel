# Keil uVision project SENS_DS18X20.uvprojx, settings and files
target ARM_Minimalsystem (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SENS_DS18X20 (library)
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\WAIT_STM32F10X
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group MYLIB
    ./: SENS_DS18X20.c SENS_DS18X20.h
  group WAIT_STM32F10X
    ./WAIT_STM32F10X/: WAIT_STM32F10X.h WAIT_STM32F10X.lib
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
