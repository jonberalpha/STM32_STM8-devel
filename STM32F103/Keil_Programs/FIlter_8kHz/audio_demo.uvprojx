# Keil uVision project audio_demo.uvprojx, settings and files
target Audio_Demo_STM32F107VC (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: audio_demo
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ./Library;./User
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.c process_data.c stm32f10x_it.c
  group Library
    ./Library/: adc_dac_lib.c dma_lib.c gpio_lib.c i2c_lib.c i2s_lib.c rcc_lib.c uart_lib.c
  group ARM20_STD
    ./Library/: ARM20_STD.lib
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev, Device:Startup 1.0.0
