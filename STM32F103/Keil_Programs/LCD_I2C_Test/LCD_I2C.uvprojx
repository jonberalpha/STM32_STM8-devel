# Keil uVision project LCD_I2C.uvprojx, settings and files
target BluePill (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LCD_I2C
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ./MYLIBS/LCD_I2C;./MYLIBS/WAIT_STM32F10X;./MYLIBS/I2C_STM32F10X
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./: main.c
  group LCD_I2C
    ./MYLIBS/LCD_I2C/: LCD_I2C.h LCD_I2C.lib
  group WAIT_STM32F10X
    ./MYLIBS/WAIT_STM32F10X/: WAIT_STM32F10X.h WAIT_STM32F10X.lib
  group I2C_STM32F10X
    ./MYLIBS/I2C_STM32F10X/: I2C_STM32F10X.h I2C_STM32F10X.lib
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
