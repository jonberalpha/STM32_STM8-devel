# Keil uVision project Digitale_Regelung.uvprojx, settings and files
target ARM_Minimalsystem (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Digitale_Regelung
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ./Application;./Libraries/Sensoren;./Libraries/Steller;./Libraries/Control;./Libraries/UART;./Libraries/SVis3;./Libraries/stm32f10x_it
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ./Application/: main.c
  group Sensoren
    ./Libraries/Sensoren/: sensoren.c sensoren.h
  group Steller
    ./Libraries/Steller/: steller.c steller.h
  group Control
    ./Libraries/Control/: control.c control.h
  group UART
    ./Libraries/UART/: uart.c uart.h
  group SvVis3
    ./Libraries/SVis3/: SvVis3.c SvVis3.h
  group IRQHandler
    ./Libraries/stm32f10x_it/: stm32f10x_it.c stm32f10x_it.h
software components: CMSIS:CORE 5.0.1, HTL Hollabrunn:Libraries:STDLib 2.0.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
