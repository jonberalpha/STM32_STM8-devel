# Keil uVision project VirtualCOMPort.uvprojx, settings and files
target BluePill (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: VirtualCOMPort
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ./inc;./src
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Applicatioin Files
    ./src/: hw_config.c LCD_4bit.c main.c stm32f10x_it.c usb_core.c usb_desc.c usb_endp.c usb_init.c usb_int.c usb_istr.c usb_mem.c usb_prop.c usb_pwr.c usb_regs.c vcom.c
    ./inc/: platform_config.h
  group Doc
    ./: readme.txt
software components: CMSIS:CORE 5.6.0, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:Flash 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
