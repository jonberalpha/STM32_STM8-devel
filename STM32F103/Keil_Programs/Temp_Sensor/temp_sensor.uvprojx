# Keil uVision project temp_sensor.uvprojx, settings and files
target ARM_Minimalsystem (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: temp_sensor
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\MYLIBS\LCD_DEM16217;.\MYLIBS\WAIT_STM32F10X;.\MYLIBS\SENS_DS18X20
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./: main.c
  group SENS_DS18X20
    ./MYLIBS/SENS_DS18X20/: SENS_DS18X20.h SENS_DS18X20.lib
  group WAIT_STM32F10X
    ./MYLIBS/WAIT_STM32F10X/: WAIT_STM32F10X.h WAIT_STM32F10X.lib
  group LCD_DEM16217
    ./MYLIBS/LCD_DEM16217/: LCD_DEM16217.h LCD_DEM16217.lib
software components: CMSIS:CORE 5.2.0, Device:Startup 1.0.0
