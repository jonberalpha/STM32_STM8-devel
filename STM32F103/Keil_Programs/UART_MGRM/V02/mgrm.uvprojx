# Keil uVision project mgrm.uvprojx, settings and files
target BluePill (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: mgrm
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ./Library
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./: gn_MGRM.c
  group Library
    ./Library/: std_stm32_f103rb.h std_stm32_f103rb.lib
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
