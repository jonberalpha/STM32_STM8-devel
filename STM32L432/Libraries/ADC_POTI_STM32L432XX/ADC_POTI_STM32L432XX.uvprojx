# Keil uVision project ADC_POTI_STM32L432XX.uvprojx, settings and files
target STM32L432KC (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L432KCUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00004000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: ADC_POTI_STM32L432XX (library)
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  group MYLIB
    ./: ADC_POTI_STM32L432XX.c ADC_POTI_STM32L432XX.h
software components: CMSIS:CORE 5.5.0, Device:Startup 1.3.1
